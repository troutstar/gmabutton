#include "draw.h"
#include <string.h>
#include <stdlib.h>
#include <math.h>

int g_fb_y_offset = 0;

static inline void put_pixel(uint16_t *fb, int x, int y, uint16_t color)
{
    int fy = y - g_fb_y_offset;
    if ((unsigned)x < SCREEN_W && (unsigned)fy < STRIP_H)
        fb[fy * SCREEN_W + x] = color;
}

void draw_pixel(uint16_t *fb, int x, int y, uint16_t color)
{
    put_pixel(fb, x, y, color);
}

void draw_fill(uint16_t *fb, uint16_t color)
{
    if (color == 0) {
        memset(fb, 0, SCREEN_W * STRIP_H * sizeof(uint16_t));
    } else {
        for (int i = 0; i < SCREEN_W * STRIP_H; i++) fb[i] = color;
    }
}

/* Multiply each channel by ~15/16 toward black. Operates on the current strip
   only (STRIP_H rows, not SCREEN_H — fixed from the klipperbridge version). */
void draw_fade(uint16_t *fb)
{
    for (int i = 0; i < SCREEN_W * STRIP_H; i++) {
        uint16_t be  = fb[i];
        uint16_t px  = (be >> 8) | (be << 8);
        uint16_t r   = (px >> 11) & 0x1F;
        uint16_t g   = (px >>  5) & 0x3F;
        uint16_t b   =  px        & 0x1F;
        r = (r * 15) >> 4;
        g = (g * 15) >> 4;
        b = (b * 15) >> 4;
        uint16_t out = (r << 11) | (g << 5) | b;
        fb[i] = (out >> 8) | (out << 8);
    }
}

void draw_line(uint16_t *fb, int x0, int y0, int x1, int y1, uint16_t color)
{
    int dx = abs(x1 - x0), sx = x0 < x1 ? 1 : -1;
    int dy = abs(y1 - y0), sy = y0 < y1 ? 1 : -1;
    int err = (dx > dy ? dx : -dy) / 2, e2;
    while (1) {
        put_pixel(fb, x0, y0, color);
        if (x0 == x1 && y0 == y1) break;
        e2 = err;
        if (e2 > -dx) { err -= dy; x0 += sx; }
        if (e2 <  dy) { err += dx; y0 += sy; }
    }
}

void draw_rect(uint16_t *fb, int x, int y, int w, int h, uint16_t color)
{
    draw_line(fb, x,     y,     x+w-1, y,     color);
    draw_line(fb, x,     y+h-1, x+w-1, y+h-1, color);
    draw_line(fb, x,     y,     x,     y+h-1, color);
    draw_line(fb, x+w-1, y,     x+w-1, y+h-1, color);
}

void draw_fill_rect(uint16_t *fb, int x, int y, int w, int h, uint16_t color)
{
    for (int row = y; row < y + h; row++)
        for (int col = x; col < x + w; col++)
            put_pixel(fb, col, row, color);
}

/* 5×7 glyph table — printable ASCII 0x20..0x7E, column-major, bit0 = top row. */
static const uint8_t s_font5x7[][5] = {
    {0x00,0x00,0x00,0x00,0x00}, {0x00,0x00,0x5F,0x00,0x00},
    {0x00,0x07,0x00,0x07,0x00}, {0x14,0x7F,0x14,0x7F,0x14},
    {0x24,0x2A,0x7F,0x2A,0x12}, {0x23,0x13,0x08,0x64,0x62},
    {0x36,0x49,0x55,0x22,0x50}, {0x00,0x05,0x03,0x00,0x00},
    {0x00,0x1C,0x22,0x41,0x00}, {0x00,0x41,0x22,0x1C,0x00},
    {0x08,0x2A,0x1C,0x2A,0x08}, {0x08,0x08,0x3E,0x08,0x08},
    {0x00,0x50,0x30,0x00,0x00}, {0x08,0x08,0x08,0x08,0x08},
    {0x00,0x60,0x60,0x00,0x00}, {0x20,0x10,0x08,0x04,0x02},
    {0x3E,0x51,0x49,0x45,0x3E}, {0x00,0x42,0x7F,0x40,0x00},
    {0x42,0x61,0x51,0x49,0x46}, {0x21,0x41,0x45,0x4B,0x31},
    {0x18,0x14,0x12,0x7F,0x10}, {0x27,0x45,0x45,0x45,0x39},
    {0x3C,0x4A,0x49,0x49,0x30}, {0x01,0x71,0x09,0x05,0x03},
    {0x36,0x49,0x49,0x49,0x36}, {0x06,0x49,0x49,0x29,0x1E},
    {0x00,0x36,0x36,0x00,0x00}, {0x00,0x56,0x36,0x00,0x00},
    {0x08,0x14,0x22,0x41,0x00}, {0x14,0x14,0x14,0x14,0x14},
    {0x00,0x41,0x22,0x14,0x08}, {0x02,0x01,0x51,0x09,0x06},
    {0x32,0x49,0x79,0x41,0x3E}, {0x7E,0x11,0x11,0x11,0x7E},
    {0x7F,0x49,0x49,0x49,0x36}, {0x3E,0x41,0x41,0x41,0x22},
    {0x7F,0x41,0x41,0x22,0x1C}, {0x7F,0x49,0x49,0x49,0x41},
    {0x7F,0x09,0x09,0x09,0x01}, {0x3E,0x41,0x49,0x49,0x7A},
    {0x7F,0x08,0x08,0x08,0x7F}, {0x00,0x41,0x7F,0x41,0x00},
    {0x20,0x40,0x41,0x3F,0x01}, {0x7F,0x08,0x14,0x22,0x41},
    {0x7F,0x40,0x40,0x40,0x40}, {0x7F,0x02,0x0C,0x02,0x7F},
    {0x7F,0x04,0x08,0x10,0x7F}, {0x3E,0x41,0x41,0x41,0x3E},
    {0x7F,0x09,0x09,0x09,0x06}, {0x3E,0x41,0x51,0x21,0x5E},
    {0x7F,0x09,0x19,0x29,0x46}, {0x46,0x49,0x49,0x49,0x31},
    {0x01,0x01,0x7F,0x01,0x01}, {0x3F,0x40,0x40,0x40,0x3F},
    {0x1F,0x20,0x40,0x20,0x1F}, {0x3F,0x40,0x38,0x40,0x3F},
    {0x63,0x14,0x08,0x14,0x63}, {0x07,0x08,0x70,0x08,0x07},
    {0x61,0x51,0x49,0x45,0x43}, {0x00,0x7F,0x41,0x41,0x00},
    {0x02,0x04,0x08,0x10,0x20}, {0x00,0x41,0x41,0x7F,0x00},
    {0x04,0x02,0x01,0x02,0x04}, {0x40,0x40,0x40,0x40,0x40},
    {0x00,0x01,0x02,0x04,0x00}, {0x20,0x54,0x54,0x54,0x78},
    {0x7F,0x48,0x44,0x44,0x38}, {0x38,0x44,0x44,0x44,0x20},
    {0x38,0x44,0x44,0x48,0x7F}, {0x38,0x54,0x54,0x54,0x18},
    {0x08,0x7E,0x09,0x01,0x02}, {0x0C,0x52,0x52,0x52,0x3E},
    {0x7F,0x08,0x04,0x04,0x78}, {0x00,0x44,0x7D,0x40,0x00},
    {0x20,0x40,0x44,0x3D,0x00}, {0x7F,0x10,0x28,0x44,0x00},
    {0x00,0x41,0x7F,0x40,0x00}, {0x7C,0x04,0x18,0x04,0x78},
    {0x7C,0x08,0x04,0x04,0x78}, {0x38,0x44,0x44,0x44,0x38},
    {0x7C,0x14,0x14,0x14,0x08}, {0x08,0x14,0x14,0x18,0x7C},
    {0x7C,0x08,0x04,0x04,0x08}, {0x48,0x54,0x54,0x54,0x20},
    {0x04,0x3F,0x44,0x40,0x20}, {0x3C,0x40,0x40,0x40,0x7C},
    {0x1C,0x20,0x40,0x20,0x1C}, {0x3C,0x40,0x30,0x40,0x3C},
    {0x44,0x28,0x10,0x28,0x44}, {0x0C,0x50,0x50,0x50,0x3C},
    {0x44,0x64,0x54,0x4C,0x44}, {0x00,0x08,0x36,0x41,0x00},
    {0x00,0x00,0x7F,0x00,0x00}, {0x00,0x41,0x36,0x08,0x00},
    {0x0C,0x02,0x0C,0x10,0x0C},
};

void draw_char(uint16_t *fb, int x, int y, char c, uint16_t color, int scale)
{
    if (c < 0x20 || c > 0x7E) c = '?';
    const uint8_t *glyph = s_font5x7[c - 0x20];
    for (int col = 0; col < 5; col++) {
        uint8_t line = glyph[col];
        for (int row = 0; row < 7; row++) {
            if (line & (1 << row)) {
                draw_fill_rect(fb, x + col * scale, y + row * scale,
                               scale, scale, color);
            }
        }
    }
}

void draw_str(uint16_t *fb, int x, int y, const char *s, uint16_t color, int scale)
{
    while (*s) {
        draw_char(fb, x, y, *s++, color, scale);
        x += 6 * scale;
    }
}

void draw_str_centered(uint16_t *fb, int y, const char *s, uint16_t color, int scale)
{
    int len = 0; for (const char *p = s; *p; ++p) len++;
    int w   = len * 6 * scale;
    int x   = (SCREEN_W - w) / 2;
    if (x < 0) x = 0;
    draw_str(fb, x, y, s, color, scale);
}

void draw_hbar(uint16_t *fb, int x, int y, int w, int h, float fill, uint16_t color)
{
    draw_rect(fb, x, y, w, h, COL_GRAY);
    int filled = (int)(fill * (w - 2));
    if (filled > 0)
        draw_fill_rect(fb, x + 1, y + 1, filled, h - 2, color);
}

void draw_filled_circle(uint16_t *fb, int cx, int cy, int r, uint16_t color)
{
    if (r <= 0) return;
    int y_lo = g_fb_y_offset;
    int y_hi = g_fb_y_offset + STRIP_H;
    for (int gy = y_lo; gy < y_hi; ++gy) {
        int dy = gy - cy;
        if (dy > r || dy < -r) continue;
        int dx = (int)sqrtf((float)(r * r - dy * dy));
        int x0 = cx - dx; if (x0 < 0) x0 = 0;
        int x1 = cx + dx; if (x1 >= SCREEN_W) x1 = SCREEN_W - 1;
        int fy = gy - g_fb_y_offset;
        uint16_t *row = fb + fy * SCREEN_W;
        for (int x = x0; x <= x1; ++x) row[x] = color;
    }
}
